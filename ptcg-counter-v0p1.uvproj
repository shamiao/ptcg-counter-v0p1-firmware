# Keil uVision project ptcg-counter-v0p1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: ptcg-counter-v0p1 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 main.c vlcd.c ht1621.c buttons.c uart.c common.c
